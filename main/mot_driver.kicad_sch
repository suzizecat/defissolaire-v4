File: main/mot_driver.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Clean silkscreen
